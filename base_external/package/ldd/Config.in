## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Includes custom kernel driver misc-modules (hello, faulty) and scull
```
